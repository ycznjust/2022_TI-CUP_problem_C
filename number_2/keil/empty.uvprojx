# Keil uVision project empty.uvprojx, settings and files
target empty (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: keil_download.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: __MSP432P401R__
  c include: ../;..\third_party\CMSIS\Include;..\src;..\code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
    ../src/: pid.c psk_DELAY.c psk_GPIO.c psk_INTERRUPT.c psk_PWM.c psk_USART.c
    ../code/: psk_OLED.c SEEKFREE_IIC.c SEEKFREE_MPU6050.c SEEKFREE_PRINTF.c psk_aht10.c posget.c psk_motor_control.c servo.c huidu.c menu.c jy901s.c ycz_distance.c ycz_communicate.c ultrasonic.c led_beep.c mission.c condition.c
  group Library
    ../ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0
